Commit message: URDF works with bunch of button clicks :(

File: install/urdf_visualization/share/urdf_visualization/urdf/model.urdf (robot description, URDF)
Before this commit: robot urdf_visualization/urdf, 7 links, 6 joints
Links:
- link base_link: mass 0.93972387307473 -> None
